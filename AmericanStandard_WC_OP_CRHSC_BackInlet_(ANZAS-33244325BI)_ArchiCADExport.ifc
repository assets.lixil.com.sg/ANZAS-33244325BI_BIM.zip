Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-09-21T09:00:30
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND
Name | FlowDirection | PortNumber | OuterDiameter (mm) = ConnectorDiameter (mm) = NominalWidth (mm) = NominalHeight (mm)
 | SOURCE | 1 | 110
 | SINK | 2 | 15

# IfcEnergyConversionDevice: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet, AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet:Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet:3778
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Cygnet; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet
Constraints - Elevation: 0 mm
Construction - ToiletBowlHole: no; ToiletLidTop: yes; WasteOffset: 260 mm
Dimensions - Area: 0.839991 m2; Volume: 0.116688 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary,Domestic Cold Water
Other - AssetIdentifier: Please record on commissioning; BarCode: Please record on commissioning; Category: Plumbing Fixtures; Family: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; Family and Type: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; InstallationDate: Please record on commissioning; SerialNumber: Please record on commissioning; Type: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; Type Id: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; WarrantyStartDate: Please record on commissioning
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Identity Data(Type) - Assembly Code: C1030200; Description: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; Keynote: N13; Manufacturer: American Standard; Model: Cygnet; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; Type Name: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/object-user-guide; BIMObjectName: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet; NBSDescription: WC pans; NBSNote: n/a; NBSObjectName: American Standard - WC pans; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-08-24 T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/cygnet-square-hygiene-rim-back-to-wall-toilet-back-inlet/document/technical-data-sheet; DurationUnit: Year; ExpectedLife: 0; Family Name: AmericanStandard_WCOnePiece_CygnetSquare_HygieneRim-BackInlet; Features: Pan: CL3324B-6DACTBI; Cistern: CL43254-6DACTBI; Seat: CL6157M-6D; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; ModelReference: Cygnet; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Cygnet Square Hygiene Rim Back to Wall Toilet - Back Inlet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
